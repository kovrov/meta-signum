RDEPENDS_${PN} += "\
 userland \
 userland-dev \
"
