IMAGE_INSTALL += "\
    packagegroup-qt5-machine-related \
    "
