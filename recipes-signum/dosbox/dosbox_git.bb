require dosbox.inc

SRCREV = "26f6d83e97e80027b77e5262a9f940e897b89c12"
