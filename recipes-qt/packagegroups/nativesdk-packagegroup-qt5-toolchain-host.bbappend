RDEPENDS_${PN} += "\
 nativesdk-wayland \
"
